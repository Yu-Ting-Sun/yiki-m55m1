# Keil uVision project DualModelPoC.uvprojx, settings and files
target ObjectTracker (6240000::V6.24::ARMCLANG)
  device: M55M1H2LJAE Nuvoton
  pack: Nuvoton.NuMicroM55_DFP.3.1.4-rc.3
  cpu: IRAM(0x20100000,0x150000) IRAM2(0x30100000,0x150000) IROM(0x00100000,0x200000) IROM2(0x10100000,0x200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: DualModelPoC
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\release\@L.bin"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: NVT_VECTOR_ON_FLASH, TF_LITE_STATIC_MEMORY, ARM_MATH_DSP, ARM_NPU
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M55M1\Include;..\..\..\..\Library\CMSIS\DSP\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\inc\npu;..\..\..\..\ThirdParty\openmv\omv\imlib;..\..\..\..\ThirdParty\openmv\omv\alloc;..\..\..\..\ThirdParty\openmv\omv\common;..\..\..\..\ThirdParty\openmv\omv\Lib;..\..\..\..\ThirdParty\tflite_micro;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-flatbuffers-src\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\api\common\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\log\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\math\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\application\main\include;..\..\..\..\ThirdParty\ml-embedded-evaluation-kit\source\profiler\include;..\Device\include;..\Model\include;..\NPU\include;..\Pattern\include;..\ProfilerCounter\include;..\ByteTrack\include;..;..\..\..\..\ThirdParty\tflite_micro\_deps\tensorflow-gemlowp-src;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\ThirdParty\eigen
  memory RVCT4: ROM 0x100000 size 0x200000
  memory RVCT5: ROM 0x10100000 size 0x200000
  memory RVCT9: RAM 0x20100000 size 0x150000
  memory RVCT10: RAM 0x30100000 size 0x150000
  scatter file: .\M55M1.scatter
  group CMSIS
    ../../../../Library/Device/Nuvoton/M55M1/Source/: startup_M55M1.c system_M55M1.c
  group Driver
    ../../../../Library/StdDriver/src/: uart.c retarget.c ccap.c clk.c sys.c gpio.c ebi.c spim_hyper.c sdh.c spi.c hsusbd.c pdma.c i2c.c i2s.c dmic.c pmc.c
    ../../../../Library/StdDriver/src/npu/: ethosu_device_u55_u65.c ethosu_driver.c ethosu_pmu.c
  group Application
    ../: BoardInit.cpp main.cpp mpu_config_M55M1.h ModelFileReader.c ModelLoader.c Slideshow.c SdSync.c Button.c VoiceRec.c VoiceChat.c Audio.c StoryUI.c day3_demo.c esp_probe.c esp_at.c esp_http.c day2_test.c tjpgd.c FaceDetect.cpp DetectorPostProcessing.cpp GestureLike.cpp FaceRecog.cpp Recognizer.cpp LabelFileReader.c
  group Lib
    ../../../../Library/CMSIS/Lib/KEIL/: cmsis_dsp.lib cmsis_nn.lib
    ../../../../ThirdParty/tflite_micro/Lib/: tflu.lib
    ../../../../ThirdParty/openmv/omv/Lib/: omv.lib
  group Model
    ../Model/: FaceModel.cpp HandLandmarkModel.cpp GestureModel.cpp NNModel.cpp NN_Model_INT8.tflite.cpp FaceMobileNetModel.cpp Labels.cpp
  group ArmMLApi
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/application/api/common/source/: Model.cc TensorFlowLiteMicro.cc ImageUtils.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/math/: PlatformMath.cc
    ../../../../ThirdParty/ml-embedded-evaluation-kit/source/profiler/: Profiler.cc
  group NPU
    ../NPU/: ethosu_cpu_cache.c ethosu_npu_init.c ethosu_profiler.c
  group ProfilerCounter
    ../ProfilerCounter/: pmu_counter.c
  group Device
    ../Device/HyperRAM/: hyperram_code.c
    ../Device/SDCard/: sdglue.c
    ../../../../Library/Storage/: diskio_SDH.c
    ../Device/Display/: Display.c Font8_16.c drv_pdma.c
    ../Device/Display/LCD/: LCD_LT7381.c LCD_FSA506.c LCD_ILI9341.c
    ../Device/ImageSensor/: ImageSensor.c
    ../Device/ImageSensor/Sensor/: Sensor_HM1055.c SWI2C.c
    ../: Camera.c
  group FatFS
    ../../../../ThirdParty/FatFs/source/: ff.c ffunicode.c
